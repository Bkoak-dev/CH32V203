## Kconfig
```kconfig
mainmenu "CH32V203 develop menu"

menu "Compile Information"

endmenu	# Compile Info
```
